# Keil uVision project ADC.uvprojx, settings and files
target ADC (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADC +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\RTC;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\SYSTEM\vgus_usart2;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\FIRE;..\HARDWARE\DHT11;..\HARDWARE\EXTIKEY;..\HARDWARE\KEY06;..\HARDWARE\REMOTE;..\HARDWARE\RC522;..\HARDWARE\ESP8266;..\SYSTEM\usart_wifi;..\SYSTEM\usart_printer;..\SYSTEM\UI;..\SYSTEM\flash;..\SYSTEM\mTimer;..\SYSTEM\IC_Card;..\SYSTEM\FunMapList;..\TCPIP;..\STM32F10x_FWLib\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/EXTIKEY/: extikey.c
    ../HARDWARE/KEY06/: key06.c
    ../HARDWARE/RC522/: rc522_config.c rc522_function.c
    ../HARDWARE/ESP8266/: wifi_config.c wifi_function.c
    ../HARDWARE/FIRE/: fire.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart_printer/: usart_printer.c
    ../SYSTEM/usart_wifi/: usart_wifi.c
    ../SYSTEM/vgus_usart2/: usart_tft.c
    ../SYSTEM/UI/: ui.c
    ../SYSTEM/flash/: flash_WR.c
    ../SYSTEM/mTimer/: mTimer.c
    ../SYSTEM/IC_Card/: IC_Card.c
    ../SYSTEM/FunMapList/: funMapList.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_dma.c
  group TCPIP
    ../TCPIP/: MessageSendandReceive.c
  group README
    ../README/: question.c
